# Keil uVision project Foundation.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Foundation +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD.USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\DataType;..\App\KeyOne;..\App\LED;..\App\OLED;..\App\PackUnpack;..\App\ProcHostCmd;..\App\SendDataToHost;..\ARM\NVIC;..\ARM\System;..\ARM\SysTick;..\HW\ADC;..\HW\Capture;..\HW\DAC;..\HW\EXTI;..\HW\Flash;..\HW\IWDG;..\HW\PWM;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/KeyOne/: KeyOne.c ProcKeyOne.c
    ../App/OLED/: OLED.c
    ../App/PackUnpack/: PackUnpack.c
    ../App/ProcHostCmd/: ProcHostCmd.c
    ../App/SendDataToHost/: SendDataToHost.c
  group HW
    ../HW/ADC/: ADC.c U16Queue.c
    ../HW/Capture/: Capture.c
    ../HW/DAC/: DAC.c Wave.c
    ../HW/EXTI/: EXTI.c
    ../HW/Flash/: Flash.c
    ../HW/IWDG/: IWDG.c
    ../HW/PWM/: PWM.c
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c UART1.c
  group FW
    ../FW/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../ARM/SysTick/: SysTick.c
